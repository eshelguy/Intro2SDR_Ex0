options:
  parameters:
    generate_options: qt_gui
    id: Ex0
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 107.5e6
  states: {}
- name: freq_slider
  id: variable_qtgui_range
  parameters:
    label: Freq_slider
    start: 88e6
    step: 0.1e6
    stop: 108e6
    value: 91.6e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: '480000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /home/eshel/Desktop/intro2SDR/ex0-audio
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    gain: '1'
    interp: '1'
    samp_rate: '48000'
    type: interp_fir_filter_fff
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: '1'
    gain: '1'
    samp_rate: 2.112e6
    type: fir_filter_ccf
    width: '50000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq_slider
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq_slider
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: 2.112e6
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc2_xx_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_rcv_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0_0, '0', analog_agc2_xx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
